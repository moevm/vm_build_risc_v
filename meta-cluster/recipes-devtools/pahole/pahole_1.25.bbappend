SRC_URI = "git://github.com/acmel/dwarves.git;branch=master;protocol=https \
           file://0002-Use-usr-bin-env-python3-instead-of-just-usr-bin-pyth.patch"
